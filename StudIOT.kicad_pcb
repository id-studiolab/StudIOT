# Repository id-studiolab/StudIOT

## KiCad design StudIOT.kicad_pcb

Parts:
C20, C21, C30, C31, C40, C50, C52, C60, C62, C110: 100nF; C_0402_1005Metric
J1, J2: Conn_01x15; PinHeader_1x15_P2.54mm_Vertical
J20, J30, J50, J60, J110: Conn_01x04; GROVE_TH_V
JP60: SolderJumper_3_Open; SolderJumper-3_P1.3mm_Open_RoundedPad1.0x1.5mm
Q30, Q40: BSS138; SOT-23
Q50, Q60: 2N7002DW; SOT-363_SC-70-6
R20, R21, R30, R40, R50, R51, R60, R61, R62: 10K; R_0402_1005Metric
R110, R112: 1K; R_0402_1005Metric
R111, R113: 2K; R_0402_1005Metric
U0: ARDUINO_NANO_33_IOT; ARDUINO_NANO_33_IOT_TH
U20: PCA9508; TSSOP-8_3x3mm_P0.65mm

Connections:
+3V3: C20.2, C30.2, C40.2, C50.1, C60.1, J1.2, JP60.3 (B), Q30.1 (G), Q40.1 (G), Q50.2 (G), Q50.5 (G), R62.1, U20.1 (VCC(A)); also elsewhere on the board
+5V: C21.1, C31.1, C52.1, C62.1, C110.1, J1.12, J20.2, J30.2, J50.2, J60.2, J110.2, JP60.1 (A), R20.1, R21.1, R30.1, R40.1, R50.1, R51.1, U20.8 (VCC(B)); also elsewhere on the board
/A0: J1.4, R110.2, R111.1
/A1: J1.5, R112.2, R113.1
/D3: J2.10, Q50.4 (S)
/D4: J2.9, Q50.1 (S)
/SCL3V3: J1.9, Q40.2 (S), Q60.4 (S), U20.2 (SCLA)
/SDA3V3: J1.8, Q30.2 (S), Q60.1 (S), U20.~ (SDAA)
GND: C20.1, C21.2, C30.1, C31.2, C40.1, C50.2, C52.2, C60.2, C62.2, C110.2, J1.14, J2.12, J20.1, J30.1, J50.1, J60.1, J110.1, R111.2, R113.2, U20.4 (GND); also elsewhere on the board
unnamed: J20.3, R21.2, U20.6 (SDAB)
unnamed: J20.4, R20.2, U20.7 (SCLB)
unnamed: J30.3, Q30.3 (D), R30.2
unnamed: J30.4, Q40.3 (D), R40.2
unnamed: J50.3, Q50.6 (D), R50.2
unnamed: J50.4, Q50.3 (D), R51.2
unnamed: J60.3, Q60.6 (D), R60.2
unnamed: J60.4, Q60.3 (D), R61.2
unnamed: J110.3, R112.1
unnamed: J110.4, R110.1
unnamed: Q60.2 (G), Q60.5 (G), R62.2
VDD: JP60.2 (C), R60.1, R61.1

Notes on the sheet:
I2C unit (may be extended to multiple I2C connectors)
Level shifter FET (discrete)
Level shifter FET (IC)
Level shifter FET (IC) Voltage switchable (3V3-5V)
D13/SCK
3V3
AREF
A0/DAC0
A4/SDA
A5/SCL
VUSB
~RST
GND
VIN
D3(PWM)
D5(PWM)
D6(PWM)
D9(PWM)
D10(PWM)
D11/MOSI
D12/MISO
Analog input

Parts:
C10: 10uF; C_0603_1608Metric
C70, C80, C90, C100: 100nF; C_0402_1005Metric
D10: RED; LED_0603_1608Metric
D11: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
D70, D71, D80, D81, D90, D91, D100, D101: 3V3; D_SOD-123
J10: Conn_01x02; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J11, J12: Conn_01x15; PinHeader_1x15_P2.54mm_Vertical
J70, J80, J90, J100: GROVE; GROVE_TH_V
Q10: Si2323; SOT-23
R10: 1K; R_0402_1005Metric
R11: 5K; R_0805_2012Metric
R12, R13: 100K; R_0402_1005Metric
R70, R71, R80, R81, R90, R91, R100, R101: 220R; R_0402_1005Metric
U10: MCP73831-2; SOT-23-5

Connections:
+3V3: C70.1, C80.1, C90.1, C100.1, J11.2, J70.2, J80.2, J90.2, J100.2; also elsewhere on the board
+5V: D10.2 (A), J11.12, U10.4 (VDD); also elsewhere on the board
/shield2/A0: D70.1 (K), J11.4, R70.2
/shield2/A1: D71.1 (K), J11.5, R71.1
/shield2/D2: D11.4 (DIN), J12.11
/shield2/D3: J12.10
/shield2/D4: J12.9
/shield2/D5: D80.1 (K), J12.8, R80.2
/shield2/D6: D81.1 (K), J12.7, R81.1
/shield2/RX: D100.1 (K), J12.14, R100.2
/shield2/SCL: D91.1 (K), J11.9, R91.1
/shield2/SDA: D90.1 (K), J11.8, R90.2
/shield2/TX: D101.1 (K), J12.15, R101.1
/shield2/V_DIV: J11.11, R12.2, R13.1
GND: C10.2, C70.2, C80.2, C90.2, C100.2, D11.3 (VSS), D70.2 (A), D71.2 (A), D80.2 (A), D81.2 (A), D90.2 (A), D91.2 (A), D100.2 (A), D101.2 (A), J10.2, J11.14, J12.12, J70.1, J80.1, J90.1, J100.1, R11.2, R13.2, U10.2 (VSS); also elsewhere on the board
unnamed: D10.1 (K), R10.1
unnamed: J70.3, R71.2
unnamed: J70.4, R70.1
unnamed: J80.3, R81.2
unnamed: J80.4, R80.1
unnamed: J90.3, R91.2
unnamed: J90.4, R90.1
unnamed: J100.3, R101.2
unnamed: J100.4, R100.1
unnamed: R10.2, U10.1 (STAT)
unnamed: R11.1, U10.5 (PROG)

Notes on the sheet:
D13/SCK
3V3
AREF
A0/DAC0
A4/SDA
A5/SCL
VUSB
~RST
GND
VIN
D3(PWM)
D5(PWM)
D6(PWM)
D9(PWM)
D10(PWM)
D11/MOSI
D12/MISO
10K - 100mA 5K - 200mA 2K - 500mA 1K - 1000mA

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
Board: 2 copper layers, 37.6 x 43.8 mm, 71 parts (60 on the bottom side), 43 nets.

## Commit log

2019-08-12 HWV1.0
2019-08-12 Hardware Version 1.0
2019-08-13 rev1
